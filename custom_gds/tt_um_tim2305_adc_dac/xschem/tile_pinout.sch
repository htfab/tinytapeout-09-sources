v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} 190 -710 0 0 {name=p1 lab=ena}
C {ipin.sym} 190 -690 0 0 {name=p2 lab=clk}
C {ipin.sym} 190 -670 0 0 {name=p3 lab=rst_n}
C {ipin.sym} 190 -640 0 0 {name=p5 lab=ui_in[0]}
C {ipin.sym} 190 -620 0 0 {name=p6 lab=ui_in[1]}
C {ipin.sym} 190 -600 0 0 {name=p7 lab=ui_in[2]}
C {ipin.sym} 190 -580 0 0 {name=p8 lab=ui_in[3]}
C {ipin.sym} 190 -560 0 0 {name=p9 lab=ui_in[4]}
C {ipin.sym} 190 -540 0 0 {name=p10 lab=ui_in[5]}
C {ipin.sym} 190 -520 0 0 {name=p11 lab=ui_in[6]}
C {ipin.sym} 190 -500 0 0 {name=p12 lab=ui_in[7]}
C {ipin.sym} 190 -470 0 0 {name=p4 lab=uio_in[0]}
C {ipin.sym} 190 -450 0 0 {name=p13 lab=uio_in[1]}
C {ipin.sym} 190 -430 0 0 {name=p14 lab=uio_in[2]}
C {ipin.sym} 190 -410 0 0 {name=p15 lab=uio_in[3]}
C {ipin.sym} 190 -390 0 0 {name=p16 lab=uio_in[4]}
C {ipin.sym} 190 -370 0 0 {name=p17 lab=uio_in[5]}
C {ipin.sym} 190 -350 0 0 {name=p18 lab=uio_in[6]}
C {ipin.sym} 190 -330 0 0 {name=p19 lab=uio_in[7]}
C {iopin.sym} 390 -840 0 0 {name=p44 lab=ua[0]}
C {iopin.sym} 390 -820 0 0 {name=p45 lab=ua[1]}
C {iopin.sym} 390 -800 0 0 {name=p46 lab=ua[2]}
C {iopin.sym} 390 -780 0 0 {name=p47 lab=ua[3]}
C {iopin.sym} 390 -760 0 0 {name=p48 lab=ua[4]}
C {iopin.sym} 390 -740 0 0 {name=p49 lab=ua[5]}
C {iopin.sym} 390 -720 0 0 {name=p50 lab=ua[6]}
C {iopin.sym} 390 -700 0 0 {name=p51 lab=ua[7]}
C {opin.sym} 390 -660 0 0 {name=p52 lab=uio_oe[0]}
C {opin.sym} 390 -640 0 0 {name=p53 lab=uio_oe[1]}
C {opin.sym} 390 -620 0 0 {name=p54 lab=uio_oe[2]}
C {opin.sym} 390 -600 0 0 {name=p55 lab=uio_oe[3]}
C {opin.sym} 390 -580 0 0 {name=p56 lab=uio_oe[4]}
C {opin.sym} 390 -560 0 0 {name=p57 lab=uio_oe[5]}
C {opin.sym} 390 -540 0 0 {name=p58 lab=uio_oe[6]}
C {opin.sym} 390 -520 0 0 {name=p59 lab=uio_oe[7]}
C {opin.sym} 390 -490 0 0 {name=p36 lab=uio_out[0]}
C {opin.sym} 390 -470 0 0 {name=p37 lab=uio_out[1]}
C {opin.sym} 390 -450 0 0 {name=p38 lab=uio_out[2]}
C {opin.sym} 390 -430 0 0 {name=p39 lab=uio_out[3]}
C {opin.sym} 390 -410 0 0 {name=p40 lab=uio_out[4]}
C {opin.sym} 390 -390 0 0 {name=p41 lab=uio_out[5]}
C {opin.sym} 390 -370 0 0 {name=p42 lab=uio_out[6]}
C {opin.sym} 390 -350 0 0 {name=p43 lab=uio_out[7]}
C {opin.sym} 390 -320 0 0 {name=p28 lab=uo_out[0]}
C {opin.sym} 390 -300 0 0 {name=p29 lab=uo_out[1]}
C {opin.sym} 390 -280 0 0 {name=p30 lab=uo_out[2]}
C {opin.sym} 390 -260 0 0 {name=p31 lab=uo_out[3]}
C {opin.sym} 390 -240 0 0 {name=p32 lab=uo_out[4]}
C {opin.sym} 390 -220 0 0 {name=p33 lab=uo_out[5]}
C {opin.sym} 390 -200 0 0 {name=p34 lab=uo_out[6]}
C {opin.sym} 390 -180 0 0 {name=p35 lab=uo_out[7]}
C {ipin.sym} 190 -300 0 0 {name=p20 lab=VDPWR}
C {ipin.sym} 190 -280 0 0 {name=p21 lab=VGND}
